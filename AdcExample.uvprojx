# Keil uVision project AdcExample.uvprojx, settings and files
target Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ADuCM360 Analog Devices
  pack: AnalogDevices.ADuCM36x_DFP.1.0.3
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AdcExample +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c include: ..\..\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ../: ADCMeter.c
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ADuCM360 Analog Devices
  pack: AnalogDevices.ADuCM36x_DFP.1.0.3
  cpu: as above
  output: AdcExample +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c include: ..\..\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
software components: CMSIS:CORE 5.0.1, Device:Drivers:ADC 1.0.0, Device:Drivers:CLK 1.0.0, Device:Drivers:DAC 1.0.0, Device:Drivers:DIO 1.0.0, Device:Drivers:DMA 1.0.0, Device:Drivers:GPT 1.0.0, Device:Drivers:I2C 1.0.0, Device:Drivers:IEXC 1.0.0, Device:Drivers:INT 1.0.0, Device:Drivers:PWM 1.0.0, Device:Drivers:URT 1.0.0, Device:Drivers:WDT 1.0.0, Device:Drivers:WUT 1.0.0, Device:Startup 1.0.0
